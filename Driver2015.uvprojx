# Keil uVision project Driver2015.uvprojx, settings and files
target STM32F405RGT6 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Driver2015 +hex
  c flags: Optim=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\sys;.\lib\inc;.\FreeRTOS;.\FreeRTOS\port\ARM_CM4F;.\FreeRTOS\include;.\driver\inc;.\app\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group FreeRTOS
    ./FreeRTOS/: list.c queue.c tasks.c croutine.c event_groups.c timers.c
    ./FreeRTOS/port/ARM_CM4F/: port.c
    ./FreeRTOS/MemMang/: heap_2.c
  group sys
    ./sys/: main.c stm32f4xx_it.c system_stm32f4xx.c startup_stm32f40xx.s
  group lib
    ./lib/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group app
    ./app/src/: canopen.c cli.c cloop.c interpolation.c ploop.c statemonitor.c vloop.c calibration.c as5047d.c tempture.c voltage.c
  group driver
    ./driver/src/: ad.c can.c encoder.c pwm.c sci.c led.c spi.c
